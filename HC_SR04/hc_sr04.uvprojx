# Keil uVision project hc_sr04.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hc_sr04 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\lib\app\delay_by_sytick;.\lib\app\HC_SR04;.\lib\app\USART1;.\lib\inc;.\lib\src;.\lib\app\TIM_Counter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./user/: main.c
  group app
    ./lib/app/delay_by_sytick/: delay_by_systick.c
    ./lib/app/HC_SR04/: hc_sr04.c hc_sr04.h
    ./lib/app/USART1/: USART1_Configuration.c USART1_Configuration.h
    ./lib/app/TIM_Counter/: TIM_Counter.c
  group start
    ./start/: cortexm3_macro.s STM32F10x.s
  group lib
    ./lib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
    ./lib/inc/: GPIOweibangding.h
